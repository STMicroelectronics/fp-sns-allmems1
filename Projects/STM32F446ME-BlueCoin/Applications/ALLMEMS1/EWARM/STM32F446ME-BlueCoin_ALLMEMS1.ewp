# IAR project STM32F446ME-BlueCoin_ALLMEMS1.ewp, settings and files
configuration STM32F446ME-BlueCoin_ALLMEMS1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F446ME ST STM32F446ME
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F446xx; USE_STM32F4XX_NUCLEO; STM32_BLUECOIN; ARM_MATH_CM4
  ICCARM.CCDiagSuppress: Pa50
  ICCARM.CCIncludePath2: ../Inc; ../../../../../Drivers/STM32F4xx_HAL_Driver/Inc; ../../../../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../../../../../Drivers/CMSIS/Include; ../../../../../Middlewares/ST/BlueNRG-MS/utils; ../../../../../Middlewares/ST/BlueNRG-MS/includes; ../../../../../Middlewares/ST/BlueNRG-MS/hci/hci_tl_patterns/Basic; ../../../../../Drivers/BSP/Components/lps22hb; ../../../../../Drivers/BSP/Components/lsm303agr; ..\..\..\..\..\Drivers\BSP\Components\lsm6dsm; ..\..\..\..\..\Drivers\BSP\Components\pcm1774; ..\..\..\..\..\Drivers\BSP\BlueCoin; ..\..\..\..\..\Middlewares\ST\STM32_AcousticBF_Library\Inc; ..\..\..\..\..\Middlewares\ST\STM32_AcousticSL_Library\Inc; ..\..\..\..\..\Middlewares\ST\STM32_BlueVoiceADPCM_Library\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Audio\Addons\PDM\Inc; ..\..\..\..\..\Middlewares\ST\STM32_MotionAR_Library\Inc; ..\..\..\..\..\Middlewares\ST\STM32_MotionFX_Library\Inc; ..\..\..\..\..\Middlewares\ST\STM32_MetaDataManager; ..\..\..\..\..\Drivers\BSP\Components\Common_ex; ..\..\..\..\..\Drivers\BSP\Components\Common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ALLMEMS1.bin
  ILINK.IlinkOutputFile: ALLMEMS1.out
  ILINK.IlinkIcfFile: stm32f446xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f446xx.s
  group Application/User
    ../Src/: AcousticBF_Manager.c AcousticSL_Manager.c AudioBV_Manager.c custom_bus.c hci_tl_interface.c HWAdvanceFeatures.c main.c MotionAR_Manager.c MotionFX_Manager.c OTA.c sensor_service.c stm32f4xx_hal_msp.c stm32f4xx_it.c TargetPlatform.c
  group Drivers/BSP/BlueCoin
    ../../../../../Drivers/BSP/BlueCoin/: BlueCoin.c BlueCoin_audio.c BlueCoin_env_sensors.c BlueCoin_motion_sensors.c BlueCoin_motion_sensors_ex.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/lps22hb/: lps22hb.c lps22hb_reg.c
    ../../../../../Drivers/BSP/Components/lsm303agr/: lsm303agr.c lsm303agr_reg.c
    ../../../../../Drivers/BSP/Components/lsm6dsm/: lsm6dsm.c lsm6dsm_reg.c
    ../../../../../Drivers/BSP/Components/pcm1774/: PCM1774.c PCM1774_reg.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_adc.c
  group Middlewares/BlueNRG-MS/Wireless/BlueNRG-MS/Controller
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c bluenrg_updater_aci.c bluenrg_utils_small.c
  group Middlewares/BlueNRG-MS/Wireless/BlueNRG-MS/HCI_TL/Basic
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/: hci_le.c
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/hci_tl_patterns/Basic/: hci_tl.c
  group Middlewares/BlueNRG-MS/Wireless/BlueNRG-MS/Utils
    ../../../../../Middlewares/ST/BlueNRG-MS/utils/: ble_list.c
  group Middlewares/MetaDataManager
    ../../../../../Middlewares/ST/STM32_MetaDataManager/: MetaDataManager.c
  group Middlewares/STM32_AcousticBF
    ../../../../../Middlewares/ST/STM32_AcousticBF_Library/Lib/: AcousticBF_CM4F_wc32_ot.a
  group Middlewares/STM32_AcousticSL
    ../../../../../Middlewares/ST/STM32_AcousticSL_Library/Lib/: AcousticSL_CM4F_wc32_ot.a
  group Middlewares/STM32_Audio_PDM
    ../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM4_IAR_wc32.a
  group Middlewares/STM32_BlueVoiceADPCM
    ../../../../../Middlewares/ST/STM32_BlueVoiceADPCM_Library/Lib/: bluevoiceADPCM_200_CM4F_IAR_ot.a
  group Middlewares/STM32_MotionAR
    ../../../../../Middlewares/ST/STM32_MotionAR_Library/Lib/: MotionAR_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionFX
    ../../../../../Middlewares/ST/STM32_MotionFX_Library/Lib/: MotionFX_CM4F_wc32_ot.a
