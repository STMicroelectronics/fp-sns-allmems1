# Keil uVision project STM32L476RG-Nucleo_IKS01A3_ALLMEMS1.uvprojx, settings and files
target STM32L476RG-Nucleo_IKS01A3_ALLMEMS1 (6180000::V6.18::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IROM(0x08004000-0x807FFFF) IRAM(0x20000000-0x20017FFF) IRAM2(0x20000000-0x20017FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: ALLMEMS1
  AfterMake: fromelf #L --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L476xx,USE_STM32L4XX_NUCLEO,STM32_NUCLEO
  c misc: -Wno-format
  c include: ../Inc;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic;../../../../../../Middlewares/ST/BlueNRG-2/utils;../../../../../../Middlewares/ST/BlueNRG-2/includes;../../../../../../Drivers/BSP/Components/lsm6dso;../../../../../../Drivers/BSP/Components/lis2dw12;../../../../../../Drivers/BSP/Components/lis2mdl;../../../../../../Drivers/BSP/Components/hts221;../../../../../../Drivers/BSP/Components/lps22hh;../../../../../../Drivers/BSP/Components/stts751;../../../../../../Drivers/BSP/IKS01A3;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/ST/STM32_AcousticSL_Library/Inc;../../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Inc;../../../../../../Middlewares/ST/STM32_MetaDataManager;../../../../../../Middlewares/ST/STM32_MotionAR_Library/Inc;../../../../../../Middlewares/ST/STM32_MotionFX_Library/Inc;../../../../../../Middlewares/ST/STM32_BLE_Manager/Inc;../../../../../../Middlewares/Third_Party/parson;../../../../../../Middlewares/ST/STM32_MotionCP_Library/Inc;../../../../../../Middlewares/ST/STM32_MotionGR_Library/Inc;../../../../../../Middlewares/ST/STM32_MotionID_Library/Inc;../../../../../../Middlewares/ST/STM32_MotionPE_Library/Inc;../../../../../../Middlewares/ST/STM32_MotionSD_Library/Inc;../../../../../../Middlewares/ST/STM32_MotionVC_Library/Inc;../../../../../../Middlewares/ST/STM32_MotionFA_Library/Inc;../../../../../../Middlewares/ST/STM32_MotionTL_Library/Inc;..\..\..\..\..\..\Drivers\BSP\CCA02M2
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x7c000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../Src/: AcousticSL_Manager.c BLE_Implementation.c hci_tl_interface.c HWAdvanceFeatures.c main.c MotionAR_Manager.c MotionCP_Manager.c MotionFA_Manager.c MotionFX_Manager.c MotionGR_Manager.c MotionID_Manager.c MotionPE_Manager.c MotionSD_Manager.c MotionTL_Manager.c MotionVC_Manager.c OTA.c stm32l4xx_hal_msp.c stm32l4xx_it.c stm32l4xx_nucleo.c stm32l4xx_nucleo_bus.c TargetPlatform.c
  group Drivers/BSP/CCA02M2
    ../../../../../../Drivers/BSP/CCA02M2/: cca02m2_audio.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../../../../Drivers/BSP/Components/lis2dw12/: lis2dw12.c lis2dw12_reg.c
    ../../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl.c lis2mdl_reg.c
    ../../../../../../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dso/: lsm6dso.c lsm6dso_reg.c
    ../../../../../../Drivers/BSP/Components/stts751/: stts751.c stts751_reg.c
  group Drivers/BSP/IKS01A3
    ../../../../../../Drivers/BSP/IKS01A3/: iks01a3_env_sensors.c iks01a3_env_sensors_ex.c iks01a3_motion_sensors.c iks01a3_motion_sensors_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Middlewares/BLE_Manager
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_AccEvent.c BLE_ActivityRecognition.c BLE_AudioLevel.c BLE_AudioSourceLocalization.c BLE_CarryPosition.c BLE_ECompass.c BLE_Environmental.c BLE_FitnessActivities.c BLE_GestureRecognition.c BLE_Inertial.c BLE_Manager.c BLE_MotionAlgorithms.c BLE_MotionIntensity.c BLE_SensorFusion.c BLE_TiltSensing.c
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/Controller
    ../../../../../../Middlewares/ST/BlueNRG-2/hci/controller/: bluenrg1_gap_aci.c bluenrg1_gatt_aci.c bluenrg1_hal_aci.c bluenrg1_l2cap_aci.c
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/HCI_TL/Basic
    ../../../../../../Middlewares/ST/BlueNRG-2/hci/: bluenrg1_devConfig.c bluenrg1_events.c bluenrg1_events_cb.c bluenrg1_hci_le.c
    ../../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic/: hci_tl.c
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/Utils
    ../../../../../../Middlewares/ST/BlueNRG-2/utils/: ble_list.c
  group Middlewares/json
    ../../../../../../Middlewares/Third_Party/parson/: parson.c
  group Middlewares/STM32_AcousticSL
    ../../../../../../Middlewares/ST/STM32_AcousticSL_Library/Lib/: AcousticSL_CM4F_wc16_ot.a
  group Middlewares/STM32_MetaDataManager
    ../../../../../../Middlewares/ST/STM32_MetaDataManager/: MetaDataManager.c
  group Middlewares/STM32_MotionAR
    ../../../../../../Middlewares/ST/STM32_MotionAR_Library/Lib/: MotionAR_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionCP
    ../../../../../../Middlewares/ST/STM32_MotionCP_Library/Lib/: MotionCP_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionFA
    ../../../../../../Middlewares/ST/STM32_MotionFA_Library/Lib/: MotionFA_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionFX
    ../../../../../../Middlewares/ST/STM32_MotionFX_Library/Lib/: MotionFX_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionGR
    ../../../../../../Middlewares/ST/STM32_MotionGR_Library/Lib/: MotionGR_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionID
    ../../../../../../Middlewares/ST/STM32_MotionID_Library/Lib/: MotionID_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionPE
    ../../../../../../Middlewares/ST/STM32_MotionPE_Library/Lib/: MotionPE_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionSD
    ../../../../../../Middlewares/ST/STM32_MotionSD_Library/Lib/: MotionSD_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionTL
    ../../../../../../Middlewares/ST/STM32_MotionTL_Library/Lib/: MotionTL_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionVC
    ../../../../../../Middlewares/ST/STM32_MotionVC_Library/Lib/: MotionVC_CM4F_wc16_ot.a
software components: CMSIS:CORE 5.6.0
