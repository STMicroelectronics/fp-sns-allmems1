<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\STM32L476JG-SensorTile_ALLMEMS1.ewp</path>
  </project>
  <batchBuild/>
</workspace>


