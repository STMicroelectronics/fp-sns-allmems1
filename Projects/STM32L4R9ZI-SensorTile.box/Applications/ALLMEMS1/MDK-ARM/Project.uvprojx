# Keil uVision project Project.uvprojx, settings and files
target STM32L4R9ZI_SensorTilebox (6180000::V6.18::ARMCLANG)
  device: STM32L4R9AIIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IROM(0x08004000-0x80FFFFF) IRAM(0x20000000-0x2009FFFF) IRAM2(0x20000000-0x2002FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: ALLMEMS1
  AfterMake: fromelf #L --bin --output=@L.bin !L
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: STM32L4R9xx,USE_HAL_DRIVER,STM32_SENSORTILEBOX
  c misc: -Wno-format
  c include: ../Inc;../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../Drivers/BSP/Components/Common;../../../../../Drivers/BSP/SensorTile.box;../../../../../Drivers/BSP/Components/hts221;../../../../../Drivers/BSP/Components/lis2mdl;../../../../../Drivers/BSP/Components/lps22hh;../../../../../Drivers/BSP/Components/lsm6dsox;../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../Middlewares/ST/STM32_MetaDataManager;../../../../../Middlewares/ST/BlueNRG-2/includes;../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic;../../../../../Middlewares/ST/BlueNRG-2/utils;../../../../../Middlewares/ST/STM32_MotionAR_Library/Inc;../../../../../Middlewares/ST/STM32_MotionCP_Library/Inc;../../../../../Middlewares/ST/STM32_MotionFX_Library/Inc;../../../../../Middlewares/ST/STM32_MotionGR_Library/Inc;../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../../../../../Middlewares/ST/STM32_MotionFA_Library/Inc;../../../../../Middlewares/ST/STM32_MotionID_Library/Inc;../../../../../Middlewares/ST/STM32_MotionPE_Library/Inc;../../../../../Middlewares/ST/STM32_MotionSD_Library/Inc;../../../../../Middlewares/ST/STM32_MotionTL_Library/Inc;../../../../../Middlewares/ST/STM32_MotionVC_Library/Inc;../../../../../Middlewares/ST/STM32_BLE_Manager/Inc;../../../../../Middlewares/Third_Party/parson
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0xfc000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl.c lis2mdl_reg.c
    ../../../../../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
    ../../../../../Drivers/BSP/Components/lsm6dsox/: lsm6dsox.c lsm6dsox_reg.c
  group Drivers/BSP/SensorTile.box
    ../../../../../Drivers/BSP/SensorTile.box/: SensorTile.box.c SensorTile.box_audio.c SensorTile.box_bc.c SensorTile.box_bus.c SensorTile.box_env_sensors.c SensorTile.box_env_sensors_ex.c SensorTile.box_motion_sensors.c SensorTile.box_motion_sensors_ex.c
  group Drivers/BSP/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_ll_sdmmc.c stm32l4xx_ll_usb.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Middlewares/BLE_Manager
    ../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_AccEvent.c BLE_ActivityRecognition.c BLE_AudioLevel.c BLE_Battery.c BLE_CarryPosition.c BLE_ECompass.c BLE_Environmental.c BLE_FitnessActivities.c BLE_GestureRecognition.c BLE_Inertial.c BLE_Manager.c BLE_MotionAlgorithms.c BLE_MotionIntensity.c BLE_SensorFusion.c BLE_TiltSensing.c
  group Middlewares/BlueNRG-2/Controller
    ../../../../../Middlewares/ST/BlueNRG-2/hci/controller/: bluenrg1_gap_aci.c bluenrg1_gatt_aci.c bluenrg1_hal_aci.c bluenrg1_l2cap_aci.c
  group Middlewares/BlueNRG-2/HCI_TL/Basic
    ../../../../../Middlewares/ST/BlueNRG-2/hci/: bluenrg1_events.c bluenrg1_events_cb.c bluenrg1_hci_le.c
    ../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic/: hci_tl.c
  group Middlewares/BlueNRG-2/Utils
    ../../../../../Middlewares/ST/BlueNRG-2/utils/: ble_list.c
  group Middlewares/json
    ../../../../../Middlewares/Third_Party/parson/: parson.c
  group Middlewares/MetaDataManager
    ../../../../../Middlewares/ST/STM32_MetaDataManager/: MetaDataManager.c
  group Middlewares/STM32_MotionAR
    ../../../../../Middlewares/ST/STM32_MotionAR_Library/Lib/: MotionAR_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionCP
    ../../../../../Middlewares/ST/STM32_MotionCP_Library/Lib/: MotionCP_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionFA
    ../../../../../Middlewares/ST/STM32_MotionFA_Library/Lib/: MotionFA_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionFX
    ../../../../../Middlewares/ST/STM32_MotionFX_Library/Lib/: MotionFX_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionGR
    ../../../../../Middlewares/ST/STM32_MotionGR_Library/Lib/: MotionGR_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionID
    ../../../../../Middlewares/ST/STM32_MotionID_Library/Lib/: MotionID_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionPE
    ../../../../../Middlewares/ST/STM32_MotionPE_Library/Lib/: MotionPE_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionSD
    ../../../../../Middlewares/ST/STM32_MotionSD_Library/Lib/: MotionSD_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionTL
    ../../../../../Middlewares/ST/STM32_MotionTL_Library/Lib/: MotionTL_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionVC
    ../../../../../Middlewares/ST/STM32_MotionVC_Library/Lib/: MotionVC_CM4F_wc16_ot.a
  group Middlewares/STM32_USBD_Library/Class/CDC
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group STM32L4R9ZI-SensorTile.box_ALLMEMS1/MDK-ARM
    ./: startup_stm32l4r9xx.s
  group STM32L4R9ZI-SensorTile.box_ALLMEMS1/User
    ../Src/: BLE_Implementation.c hci_tl_interface.c HWAdvanceFeatures.c main.c MotionAR_Manager.c MotionCP_Manager.c MotionFA_Manager.c MotionFX_Manager.c MotionGR_Manager.c MotionID_Manager.c MotionPE_Manager.c MotionSD_Manager.c MotionTL_Manager.c MotionVC_Manager.c OTA.c stm32l4xx_hal_msp.c stm32l4xx_it.c TargetPlatform.c usbd_cdc_interface.c usbd_conf.c usbd_desc.c
software components: CMSIS:CORE 5.6.0
