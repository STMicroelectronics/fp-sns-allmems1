<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32F446RE-Nucleo_IKS01A3_ALLMEMS1.ewp</path>
  </project>
  <batchBuild />
</workspace>
